# IAR project smart_lock_cm33_core0.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S69_core0 NXP LPC55S69_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: DEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33; MULTICORE_APP=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; CMSIS; component/lists; component/serial_manager; component/uart; device; doc; drivers; mcmgr; rpmsg_lite; rpmsg_lite/env/bm; rpmsg_lite/porting; src; startup; utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: smart_lock_cm33_core0.out
  ILINK.IlinkKeepSymbols: smart_lock_cm33_core1_image
  ILINK.IlinkConfigDefines: __stack_size__=0x400; __heap_size__=0x2000; __use_shmem__=1
  ILINK.IlinkIcfFile: LPC55S69_cm33_core0_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 60
  ICCARM.CCDefines: NDEBUG; CORE1_IMAGE_COPY_TO_RAM; CPU_LPC55S69JBD100_cm33_core0; ARM_MATH_CM33; MULTICORE_APP=1
  ICCARM.CCOptLevel: 3
  AARM.ADefines: NDEBUG
  ILINK.IlinkKeepSymbols: smart_lock_cm33_core1_image; _rpmsg_lite_pingpong_cm33_core1_image
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm33.h mpu_armv7.h mpu_armv8.h tz_context.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: uart.h usart_adapter.c
  group device
    device/: fsl_device_registers.h LPC55S69_cm33_core0.h LPC55S69_cm33_core0_features.h system_LPC55S69_cm33_core0.c system_LPC55S69_cm33_core0.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_iocon.h fsl_mailbox.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_usart.c fsl_usart.h
  group libs
    libs/: iar_lib_power.a
  group mcmgr
    mcmgr/: mcmgr.c mcmgr.h mcmgr_internal_core_api.h mcmgr_internal_core_api_lpc55s69.c readme.txt
  group mcmgr/doc
    mcmgr/doc/: all_0.html all_1.html all_2.html customdoxygen.css dir_68267d1309a1af8e8297ef4c3efbcdba.html doxygen.css enums_0.html enums_1.html enumvalues_0.html functions_0.html group__mcmgr.html groups_0.html index.html mcmgr_8h_source.html modules.html navtree.css nomatches.html pages_0.html search.css tabs.css typedefs_0.html
  group rpmsg_lite
    rpmsg_lite/: llist.c llist.h readme.txt rpmsg_compiler.h rpmsg_default_config.h rpmsg_lite.c rpmsg_lite.h rpmsg_ns.c rpmsg_ns.h virtio_ring.h virtqueue.c virtqueue.h
  group rpmsg_lite/doc
    rpmsg_lite/doc/: all_0.html all_1.html all_2.html all_3.html all_4.html all_5.html all_6.html all_7.html classes_0.html customdoxygen.css dir_5a30104352ef4255dc24354b02eb2d20.html dir_97aefd0d527b934f1d99a682da8fe6a9.html doxygen.css files_0.html functions_0.html group__config.html group__rpmsg__lite.html group__rpmsg__ns.html group__rpmsg__queue.html groups_0.html index.html modules.html navtree.css nomatches.html pages_0.html rpmsg__default__config_8h.html rpmsg__default__config_8h_source.html rpmsg__lite_8h_source.html rpmsg__ns_8h_source.html rpmsg__queue_8h_source.html search.css tabs.css typedefs_0.html variables_0.html variables_1.html variables_2.html variables_3.html variables_4.html variables_5.html variables_6.html variables_7.html
  group rpmsg_lite/env/bm
    rpmsg_lite/env/bm/: rpmsg_env.h rpmsg_env_bm.c
  group rpmsg_lite/porting
    rpmsg_lite/porting/: rpmsg_platform.c rpmsg_platform.h
  group source
    source/: Common.h main_master.c MqttKit.c MqttKit.h rpmsg_config.h
  group src
    src/: LPC55S69_cm33_core0_flash.icf
  group startup
    startup/: startup_LPC55S69_cm33_core0.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
